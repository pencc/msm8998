## drivers/nnvram/Kconfig
```kconfig
config NNVRAM
	tristate "nvram driver"
	default n
	help
	nvram driver for Linux.
```
